# Keil uVision project template.uvprojx, settings and files
target template_Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L136.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\common;..\source;..\driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c Key.c Key.h Timer.c Timer.h Serial.c Serial.h LED.c LED.h
  group driver
    ../driver/: adc.c adc.h adt.c adt.h aes.c aes.h bgr.c bgr.h bt.c bt.h ddl.c ddl.h debug.c debug.h dmac.c dmac.h flash.c flash.h gpio.c gpio.h hdiv.c hdiv.h i2c.c i2c.h lcd.c lcd.h lpm.c lpm.h lptim.c lptim.h lpuart.c lpuart.h lvd.c lvd.h opa.c opa.h pca.c pca.h pcnt.c pcnt.h reset.c reset.h rtc.c rtc.h spi.c spi.h sysctrl.c sysctrl.h trim.c trim.h trng.c trng.h uart.c uart.h vc.c vc.h wdt.c wdt.h
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
